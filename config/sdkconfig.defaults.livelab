## recovery/main/Kconfig.projbuild
```kconfig
menu "Recovery"
    config RECOVERY_SIM
        bool "QEMU simulator build (OpenCores virtual NIC instead of WiFi)"
        default n
endmenu
```
